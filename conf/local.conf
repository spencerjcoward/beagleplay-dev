## conf/local.conf
```bitbake
MACHINE = "beagleplay-dev"
BEAGLEPLAY_IPADDR = "192.168.0.10"
BEAGLEPLAY_HOSTIP = "192.168.0.254"
BEAGLEPLAY_NFSROOT = "\/tftpboot"
OE_TERMINAL="xterm"
```
